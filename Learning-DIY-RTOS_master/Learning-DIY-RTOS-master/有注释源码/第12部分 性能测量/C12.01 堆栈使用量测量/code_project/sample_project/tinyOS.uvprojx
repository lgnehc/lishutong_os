# Keil uVision project tinyOS.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: tinyOS
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./Source/: main.c switch.c tinyOS.h tBitmap.c tLib.h tConfig.h tList.c app.c tCpu.c tTask.c tTime.c tEvent.c tSem.c tMBox.c tMemBlock.c tFlagGroup.c tMutex.c tTimer.c tMBox.h tMemBlock.h tSem.h tTask.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
